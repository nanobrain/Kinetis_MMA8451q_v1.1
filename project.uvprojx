# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Listings\Device\MKL25Z4;.\Listings\User;.\Listings\RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group RTOS
    ./Listings/RTOS/: HD44780_Th.c main.c MMA8451Q_Th.c
    ./: SVC_Table.s
  group Device
    ./Listings/Device/MKL25Z4/: core_cm0plus.h core_cmFunc.h core_cmInstr.h fsl_bitaccess.h MKL25Z4.h MKL25Z4_adc.h MKL25Z4_cmp.h MKL25Z4_dac.h MKL25Z4_dma.h MKL25Z4_dmamux.h MKL25Z4_fgpio.h MKL25Z4_ftfa.h MKL25Z4_gpio.h MKL25Z4_i2c.h MKL25Z4_llwu.h MKL25Z4_lptmr.h MKL25Z4_mcg.h MKL25Z4_mcm.h MKL25Z4_memory.h MKL25Z4_mtb.h MKL25Z4_mtbdwt.h MKL25Z4_nv.h MKL25Z4_osc.h MKL25Z4_pins.h MKL25Z4_pit.h MKL25Z4_pmc.h MKL25Z4_port.h MKL25Z4_rcm.h MKL25Z4_rom.h MKL25Z4_rtc.h MKL25Z4_sim.h MKL25Z4_smc.h MKL25Z4_spi.h MKL25Z4_tpm.h MKL25Z4_tsi.h MKL25Z4_uart.h MKL25Z4_uart0.h MKL25Z4_usb.h system_MKL25Z4.h
  group User
    ./Listings/User/: Delay.c Delay.h fsl_device_registers.h HD44780.c HD44780.h I2C.c I2C.h LED.c LED.h Low_Level_Init.c Low_Level_Init.h MMA8451Q_Drv.c MMA8451Q_Drv.h
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.0
